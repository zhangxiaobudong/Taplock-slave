# Keil uVision project Test bench slave.uvproj, settings and files
target Target 1 (MCS-51)
  device: STC15W408AS Series STC
  cpu: IRAM(0-0xFF) XRAM(0-0xFF) IROM(0-0x1FF8) CLOCK(35000000) MODP2
  output: Test bench slave +hex
  c flags: Optimize=8 SizeSpeed=1
  c include: .\C and H
  group Source Group 1
    ./: STARTUP.A51
    ./C and H/: ADC_Drive.c ASCLL.c Cylinder_Drive.c EEPROM.c IIC_Drive.c KEY_Drive.c LED_Drive.c Lock_Drive.c main.c OLED_Drive.c RS485_Drive.c
  group include
    ./C and H/: ADC_Drive.h all.h ASCLL.h Cylinder_Drive.h EEPROM.h IIC_Drive.h KEY_Drive.h LED_Drive.h Lock_Drive.h OLED_Drive.h RS485_Drive.h
